# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F446R (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F446R
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,
  c include: ..\;..\Libraries\CMSIS;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32F4xx_HAL_Driver\Src;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f446xx.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c
    ../Program/: stm32f4xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c stm32f4_usart.c
  group Program
    ../Program/: experiment_stm32f4.c experiment_stm32f4_it.c experiment_stm32f4_msp.c
  group Module
    ../Program/modules/: module_serial.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c

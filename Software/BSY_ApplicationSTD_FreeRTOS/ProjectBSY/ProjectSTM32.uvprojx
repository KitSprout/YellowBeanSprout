# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F446R (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F446R
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F446xx, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\MemMang;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/: system_stm32f4xx.c startup_stm32f446xx.s
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: cmsis_os.c
    ../Libraries/FreeRTOS/Source/: list.c timers.c tasks.c queue.c
    ../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Program
    ../Program/: main.c beanSproutY.c beanSproutY_bsp.c beanSproutY_it.c
